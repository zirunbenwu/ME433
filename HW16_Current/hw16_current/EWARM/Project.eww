<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\hw16_current.ewp</path>
  </project>
  <batchBuild />
</workspace>
